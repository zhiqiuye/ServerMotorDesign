# Keil uVision project stm32f4 ucosii.uvprojx, settings and files
target uCOSII 2.92 V1.3 (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BLDC Driver +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __FPU_PRESENT,__FPU_USED,__CC_ARM,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__TARGET_FPU_SOFTVFP
  c include: .\CMSIS;.\Liberaries;.\Liberaries\inc;.\Liberaries\src;.\User;.\UCOSII\ucosii_cpu;.\UCOSII\ucosii_lib;.\UCOSII\ucosii_port;.\UCOSII\ucosii_src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c app.c peripherial_init.c motor_control.c spd_pos_filter.c current_filter.c global_parameters.c hall_reversal_svpwm.c hall_reversal_6steps.c stm32f4xx_it.c delay.c system_stm32f4xx.c jingle_math.c node_can_config.c
  group CMSIS
    ./CMSIS/: startup_stm32f40xx.s
  group Libraries
    ./Liberaries/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ./Liberaries/: arm_cortexM4lf_math.lib
  group uCOS_II_Port
    ./UCOSII/ucosii_port/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS_II_Lib
    ./UCOSII/ucosii_lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uCOS_II_CPU
    ./UCOSII/ucosii_cpu/: cpu_a.asm cpu_c.c cpu_core.c
  group uCOS_II_Src
    ./UCOSII/ucosii_src/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group Doc
    ./: PinMap.txt Instruction.txt
